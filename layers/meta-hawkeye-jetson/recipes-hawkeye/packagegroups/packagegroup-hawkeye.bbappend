# The 4.9 linux-tegra kernel does not support wireguard so include
# the external module.
#RDEPENDS_${PN}-base += " wireguard-module"
